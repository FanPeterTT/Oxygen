# Keil uVision project STM32F030CCTX.uvprojx, settings and files
target STM32F030CCTX (ARM-ADS)
  device: STM32F030CC STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32F030CCTX +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F030xC
  c include: ../Inc;                                     .\my_code;                                ../Drivers/STM32F0xx_HAL_Driver/Inc;                                ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;                                ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;           ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/User
    ../Src/: main.c gpio.c adc.c dma.c rtc.c sys.c tim.c usart.c stm32f0xx_it.c stm32f0xx_hal_msp.c
  group Drivers/CMSIS
    ./: startup_stm32f030xc.s
    ../Src/: system_stm32f0xx.c
  group my_code
    ./my_code/: my_dma.c my_flash.c my_gpio.c my_key.c my_rtc.c my_sensor.c my_standby.c my_switch.c my_tim.c my_uart.c bc20.c my_fifo.c my_iic.c my_oled.c my_global.c my_main.c my_motor.c my_bmp.c fonts.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_exti.c stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c
software components: CMSIS:CORE 5.0.1
